# Keil uVision project egpio.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODAT2
  output: filament +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: STARTUP.A51 Main.c USART.c GPIO.c
